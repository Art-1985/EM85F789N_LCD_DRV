# Keil uVision project EM85F789N_LCD_DRV.uvproj, settings and files
target Target 1 (MCS-51)
  device: EM85F789N Elan
  cpu: IRAM(0-0xFF) IROM(0-0x47FF) XRAM (0-0x02FF) CLOCK(20000000)
  output: EM85F789N_LCD_DRV +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Inc
  group StartUp
    ./: STARTUP.A51
  group Src
    ./Src/: MAIN.c EM85FxxxN_SysCtrl.c EM85FxxxN_EINT.c EM85FxxxN_GPIO.c EM85FxxxN_LVD.c EM85FxxxN_LCD.c EM85F789N_InitialTable.c
  group Inc
    $TC_ROOT$/../../Users/02072/Documents/GitHub/EM85F789N_LCD_DRV/Inc/: EM85F789N.h EM85F789N.inc EM85FxxxN_ADC.h EM85FxxxN_CMP.h EM85FxxxN_Device.h EM85FxxxN_EINT.h EM85FxxxN_GPIO.h EM85FxxxN_I2C.h EM85FxxxN_IAP.h EM85FxxxN_LCD.h EM85FxxxN_LVD.h EM85FxxxN_OZ.h EM85FxxxN_PWM.h EM85FxxxN_SPI.h EM85FxxxN_SysCtrl.h EM85FxxxN_TIM.h EM85FxxxN_UART.h
